options:
  parameters:
    generate_options: qt_gui
    id: test1
    output_language: python
    title: Testcase1
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 8*divider*sps-1
    value: '10'
  states: {}
- name: divider
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '3000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (154,154,154,154,154,154,154,154)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps*divider
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '2000000'
    buffer_size: '327680'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: samp_rate_rx
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '327680'
    frequency: '2400000000'
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate_rx
  states: {}
- name: lab_radar_signal_corr_estimator_cf_0
  id: lab_radar_signal_corr_estimator_cf
  parameters:
    avg_length: '10'
    code_length: '8'
    sample_fac: divider
    sample_rate_rx: samp_rate_rx
    skip_data: '60'
    sps_rx: sps
    v_max: '10'
  states: {}
- name: lab_radar_simple_decimator_cc_0
  id: lab_radar_simple_decimator_cc
  parameters:
    decimation: divider
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate_rx/sps/8
    type: float
  states: {}

connections:
- [blocks_delay_0, '0', lab_radar_simple_decimator_cc_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_delay_0, '0']
- [digital_constellation_modulator_0, '0', lab_radar_signal_corr_estimator_cf_0, '1']
- [iio_pluto_source_0, '0', lab_radar_signal_corr_estimator_cf_0, '0']
- [lab_radar_signal_corr_estimator_cf_0, '0', qtgui_time_sink_x_0, '0']
- [lab_radar_signal_corr_estimator_cf_0, '1', qtgui_time_sink_x_0, '1']
- [lab_radar_signal_corr_estimator_cf_0, '2', qtgui_time_sink_x_0, '2']
- [lab_radar_simple_decimator_cc_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
